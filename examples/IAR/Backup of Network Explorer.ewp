# IAR project Backup of Network Explorer.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 200
  General.GHeapSize2: 30
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD; ZM_PHY_SPI; REGION_NORTH_AMERICA; USE_STDIO; xMODULE_INTERFACE_VERBOSE; VERBOSE_ERROR_HANDLING; xZM_PHY_SPI_VERBOSE_ERRORS; _new_below_; DISCOVER_NETWORKS; INCLUDE_NETWORK_TOPOLOGY; xINCLUDE_PERMIT_JOIN
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -Omsp430_txt
  group (top)
    ../: example_network_explorer.c module_example_utils.c set.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_fram.c hal_launchpad.c hal_mdb1.c hal_mdb2.c hal_msp430x2xxx_oscillators.c hal_msp430x2xxx_usci.c
  group ZM
    ../../ZM/: af.c application_configuration.c module.c module_errors.c module_utilities.c zdo.c zm_phy_spi.c zm_phy_uart.c
