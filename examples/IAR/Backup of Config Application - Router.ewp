# IAR project Backup of Config Application - Router.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 270
  General.GHeapSize2: 30
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD; ZM_PHY_SPI; xINCLUDE_IR_TEMPERATURE_SENSOR; INCLUDE_COLOR_SENSOR; INCLUDE_SUPPLY_VOLTAGE; VERBOSE_ERROR_HANDLING; xMODULE_INTERFACE_VERBOSE; INCLUDE_SENSOR_PARAMETERS
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -Omsp430_txt
  group (top)
    ../: example_config_application_router_afzdo.c module_example_utils.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_AMS_TCS3414_color_sensor.c hal_bit_bang_i2c.c hal_launchpad.c hal_TI_TMP006_IR_temperature_sensor.c
  group Messages
    ../Messages/: configRequestMessage.c configResponseMessage.c header.c infoMessage.c
  group ZM
    ../../ZM/: af.c application_configuration.c module.c module_errors.c module_utilities.c zdo.c zm_phy_spi.c
